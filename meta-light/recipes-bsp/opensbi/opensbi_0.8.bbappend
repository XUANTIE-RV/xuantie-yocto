COMPATIBLE_MACHINE = "ice|light-fm|light-mpw|light-fm-fpga|light-fm-*"
