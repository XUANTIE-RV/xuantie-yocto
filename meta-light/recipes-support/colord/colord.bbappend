do_install_append() {
    rm -f ${D}/usr/libexec/colord
}
