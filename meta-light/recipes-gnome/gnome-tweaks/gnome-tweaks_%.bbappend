FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
  
SRC_URI_append = " file://0001-Port-to-libhandy-1.patch"
