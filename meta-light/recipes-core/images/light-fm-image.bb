DESCRIPTION = "A full image for light fm."

require light-fm-image-bsp.bb
require light-fm-image-test.bb

export IMAGE_BASENAME = "light-fm-image"
