FILES_${PN}_append = " ${libdir}/libOpenCL.so.1 "
