FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append_d1 = " \
    file://interfaces \
"