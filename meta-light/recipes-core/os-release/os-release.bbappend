OS_RELEASE_FIELDS_append = " BUILD_ID HOME_URL "
HOME_URL = "https://occ.t-head.cn/"
