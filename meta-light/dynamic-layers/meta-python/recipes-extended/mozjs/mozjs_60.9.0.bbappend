FILESEXTRAPATHS_prepend := "${THISDIR}/mozjs:"

SRC_URI += " file://0001-mozjs-a-workaround-for-gnome-shell-hang.patch"
