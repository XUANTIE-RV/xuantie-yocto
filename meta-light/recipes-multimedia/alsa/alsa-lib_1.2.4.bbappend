EXTRA_OECONF_append_d1 = " \
    --with-versioned=no \
"
