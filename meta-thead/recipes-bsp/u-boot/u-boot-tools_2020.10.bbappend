

SRC_URI = "git://git@gitee.com/t-head-linux/u-boot.git;protocol=https \
          "
