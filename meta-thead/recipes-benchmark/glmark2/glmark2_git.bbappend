
SRC_URI = " \
    git://git@gitee.com/t-head-linux/glmark2.git;protocol=https \
    file://0001-fix-dispmanx-build.patch \
    file://0002-run-dispmanx-fullscreen.patch \
    file://0003-fix-precision-handling-bugs.patch \
    "
