
SRC_URI = "git://git@gitee.com/t-head-linux/shared-mime-info.git;protocol=https"
