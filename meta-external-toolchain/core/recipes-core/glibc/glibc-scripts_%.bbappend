require recipes-external/glibc/glibc-external-version.inc
