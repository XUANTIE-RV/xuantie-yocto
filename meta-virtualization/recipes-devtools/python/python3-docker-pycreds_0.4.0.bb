inherit pypi setuptools3
require python-docker-pycreds.inc

