DUMMYARCH = "container-dummy-provides"
DUMMYPROVIDES = "\
   /bin/sh \
   /usr/bin/env \
"
require recipes-core/meta/dummy-sdk-package.inc
