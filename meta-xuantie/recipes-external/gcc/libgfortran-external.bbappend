EXTERNAL_PROVIDE_PATTERN = "${FILES:${PN}}"
DEPENDS:append = " virtual/libc "
