SRC_URI = "git://git@gitee.com/t-head-linux/assimp.git;branch=assimp_5.0_release;protocol=https \
           file://0001-closes-https-github.com-assimp-assimp-issues-2733-up.patch \
           file://0001-Use-ASSIMP_LIB_INSTALL_DIR-to-search-library.patch \
           "

SRCREV = "8f0c6b04b2257a520aaab38421b2e090204b69df"

