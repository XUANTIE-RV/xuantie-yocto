
SRC_URI = "git://git@gitee.com/t-head-linux/Vulkan-Loader.git;branch=sdk-1.2.154"

