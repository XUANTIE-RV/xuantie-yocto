
SRC_URI = "git://git@gitee.com/t-head-linux/Vulkan-Headers.git;branch=master"
