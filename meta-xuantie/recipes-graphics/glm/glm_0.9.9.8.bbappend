
SRC_URI = " \
    git://git@gitee.com/t-head-linux/glm.git;branch=master;protocol=https \
    file://0001-Silence-clang-warnings.patch \
    file://glmConfig.cmake.in \
    file://glmConfigVersion.cmake.in \
    file://glm.pc.in \
    file://glmTargets.cmake \
"
