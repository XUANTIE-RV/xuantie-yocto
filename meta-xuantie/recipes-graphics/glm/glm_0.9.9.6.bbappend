
SRC_URI = " \
    git://git@gitee.com/t-head-linux/glm.git;branch=master \
    file://0001-Fix-Wimplicit-int-float-conversion-warnings-with-cla.patch \
    file://glmConfig.cmake.in \
    file://glmConfigVersion.cmake.in \
    file://glm.pc.in \
    file://glmTargets.cmake \
"
