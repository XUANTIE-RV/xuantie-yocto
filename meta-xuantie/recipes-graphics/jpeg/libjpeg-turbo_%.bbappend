inherit xuantie-prebuilt-src
