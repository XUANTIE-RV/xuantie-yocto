CFLAGS:append:libc-musl = " -D_LARGEFILE64_SOURCE"
