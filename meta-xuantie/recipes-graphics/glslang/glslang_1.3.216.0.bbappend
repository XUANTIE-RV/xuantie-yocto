SRC_URI = "git://github.com/KhronosGroup/glslang.git;protocol=https;branch=main \
        file://0001-generate-glslang-pkg-config.patch"
