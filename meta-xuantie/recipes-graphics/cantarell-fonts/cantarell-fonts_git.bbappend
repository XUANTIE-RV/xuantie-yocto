
SRC_URI = "git://git@gitee.com/t-head-linux/cantarell-fonts.git;protocol=https;branch=reconstruction-0.0.25"
