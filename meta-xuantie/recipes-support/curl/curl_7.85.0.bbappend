EXTRA_OECONF:remove = "--disable-curldebug"
