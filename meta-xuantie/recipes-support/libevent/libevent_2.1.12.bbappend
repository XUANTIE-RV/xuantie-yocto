PACKAGECONFIG:append:libc-glibc = " openssl"
