EXTRA_OECONF:append = " --disable-cxx-exceptions"
