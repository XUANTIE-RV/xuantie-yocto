inherit xuantie-gcc-compatible
