CXXFLAGS:append:libc-musl = " -DGNULIB_NAMESPACE=gnulib"
