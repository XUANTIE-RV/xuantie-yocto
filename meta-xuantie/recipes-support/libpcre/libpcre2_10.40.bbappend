BINCONFIG = ""

# benchmark binaries link fully static (benchmark bbclass LDFLAGS has -static);
# regex-benchmark-pcre2 needs libpcre2-8.a in the sysroot
DISABLE_STATIC = ""
