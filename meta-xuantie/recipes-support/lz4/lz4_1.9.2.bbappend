
SRCREV = "fdf2ef5809ca875c454510610764d9125ef2ebbd"

SRC_URI = "git://github.com/lz4/lz4.git;branch=dev \
           file://run-ptest \
           "
