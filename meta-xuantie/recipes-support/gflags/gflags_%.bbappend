# build staticdev package also
EXTRA_OECMAKE += " -DBUILD_STATIC_LIBS=ON"
