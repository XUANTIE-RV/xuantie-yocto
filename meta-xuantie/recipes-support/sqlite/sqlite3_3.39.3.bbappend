EXTRA_OECONF:remove = " --disable-static-shell"
EXTRA_OECONF:append = " --enable-static-shell"
