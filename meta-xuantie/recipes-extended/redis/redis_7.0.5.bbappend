DEPENDS += "openssl"
EXTRA_OEMAKE += "BUILD_TLS=yes"
