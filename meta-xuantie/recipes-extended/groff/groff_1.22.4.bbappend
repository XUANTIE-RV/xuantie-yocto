inherit xuantie-clang18-compatible
