
SRC_URI = "git://git@gitee.com/t-head-linux/procps.git;protocol=https \
           file://sysctl.conf \
           "
