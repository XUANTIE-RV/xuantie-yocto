HOST_CC_ARCH:remove:toolchain-clang = "-target ${HOST_SYS}"
