
# fix error in xuantie-yocto
# TODO. check posix-spawn with team:OS-tools
EXTRA_OECONF += "--disable-posix-spawn"
