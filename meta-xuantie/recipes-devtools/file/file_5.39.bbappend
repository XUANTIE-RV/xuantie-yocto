
SRC_URI = "git://git@gitee.com/t-head-linux/file.git \
           file://0001-src-compress.c-correct-header-define-for-xz-lzma.patch"

