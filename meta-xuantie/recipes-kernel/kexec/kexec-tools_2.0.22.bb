SUMMARY = "Kexec fast reboot tools"
DESCRIPTION = "Kexec is a fast reboot feature that lets you reboot to a new Linux kernel"
AUTHOR = "Eric Biederman"
HOMEPAGE = "https://github.com/riscv-collab/kexec-tools/tree/riscv"
SECTION = "kernel/userland"
LICENSE = "GPL-2.0-only"

LIC_FILES_CHKSUM = ""
LIC_FILES_CHKSUM = "file://COPYING;md5=ea5bed2f60d357618ca161ad539f7c0a"
DEPENDS = "zlib xz"

SRC_URI = "git://github.com/riscv-collab/kexec-tools.git;protocol=https;branch=riscv;"
SRCREV = "379d8f3ef3219bd400c7893d0a262b079c1de408"

S = "${WORKDIR}/git"
inherit autotools

#export LDFLAGS = "-L${STAGING_LIBDIR}"
EXTRA_OECONF = " --with-zlib=yes --with-lzma=yes"

do_compile:prepend() {
    # Remove the prepackaged config.h from the source tree as it overrides
    # the same file generated by configure and placed in the build tree
    rm -f ${S}/include/config.h

    # Remove the '*.d' file to make sure the recompile is OK
    for dep in `find ${B} -type f -name '*.d'`; do
        dep_no_d="`echo $dep | sed 's#.d$##'`"
        # Remove file.d when there is a file.o
        if [ -f "$dep_no_d.o" ]; then
            rm -f $dep
        fi
    done
}

do_install() {
    oe_runmake install DESTDIR=${D}

    rm -f ${D}${sbindir}/vmcore-dmesg
    rm -rf ${D}${datadir}
}

COMPATIBLE_HOST = '(x86_64.*|i.86.*|arm.*|aarch64.*|riscv64.*|powerpc.*|mips.*)-(linux|freebsd.*)'
