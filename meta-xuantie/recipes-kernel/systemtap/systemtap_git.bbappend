inherit xuantie-gcc14-compatible
