FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Fix-build-khv-error-to-add-libfdt-static-library.patch"

