# thrift 0.17.0 在 clang 下因 boost/mpl integral_wrapper 触发
# -Wenum-constexpr-conversion 报错，继承兼容类抑制
inherit xuantie-clang-compatible
