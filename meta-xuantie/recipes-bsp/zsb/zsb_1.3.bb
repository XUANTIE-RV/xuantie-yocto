require zsb.inc

# feature: Update for C950 
SRCREV = "6d1563d5c39d4dbe7b28c2702df19989ba358a41"