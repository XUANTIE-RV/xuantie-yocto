require u-boot-common-2020.10.inc
require u-boot-2020.10.inc

DEPENDS += "bc-native dtc-native"

