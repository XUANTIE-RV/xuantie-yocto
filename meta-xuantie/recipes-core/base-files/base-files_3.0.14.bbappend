dirs1777 += "${localstatedir}/crash"
