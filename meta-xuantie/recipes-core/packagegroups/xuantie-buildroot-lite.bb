DESCRIPTION = "This packagegroup includes buildroot lite"
LICENSE = "MIT"

IMAGE_INSTALL += " bc dos2unix eject fio iperf3  lsscsi  libnl  tree expect tcl bash-completion glib-networking libssh shadow xz "
