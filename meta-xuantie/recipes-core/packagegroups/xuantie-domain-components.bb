DESCRIPTION = "This packagegroup includes domain components"
LICENSE = "MIT"

IMAGE_INSTALL += "  "
