inherit xuantie-clang18-compatible xuantie-gcc14-compatible
