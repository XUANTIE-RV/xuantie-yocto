FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Resolve-incorrect-float-ABI-flag-settings-for-RISC-V.patch"
