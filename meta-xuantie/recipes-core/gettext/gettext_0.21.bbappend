inherit xuantie-clang-compatible
