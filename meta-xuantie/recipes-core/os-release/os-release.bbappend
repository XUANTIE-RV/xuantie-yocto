OS_RELEASE_FIELDS:append = " BUILD_ID HOME_URL ID_LIKE "
HOME_URL = "https://xrvm.cn/"
ID_LIKE = "yocto"
