SRC_URI = "git://github.com/libbpf/libbpf.git;protocol=https;branch=libbpf-0.8.1"
SRCREV = "d4fc7a517676078d9e79dc3a6b5aa28b1c90e7e4"