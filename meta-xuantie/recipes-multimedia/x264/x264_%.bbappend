inherit xuantie-prebuilt-src
SRCPV:xuantie-buildmode-prebuilt:class-target = ""
