do_fetch_git_submodule[network] = "1"
do_compile[network] = "1"
do_install[network] = "1"
