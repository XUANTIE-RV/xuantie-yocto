## meta-xuantie/conf/distro/include/softfloat.inc
```bitbake
XUANTIE_MARCH:riscv64 = "rv64imac"
XUANTIE_MABI:riscv64 = "lp64"
XUANTIE_MARCH:riscv32 = "rv32imac"
XUANTIE_MABI:riscv32 = "ilp32"
```
