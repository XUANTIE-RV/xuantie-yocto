FILESEXTRAPATHS:prepend := "${THISDIR}/libtool:"

SRC_URI += "file://9999-fix-xuantie.patch"
