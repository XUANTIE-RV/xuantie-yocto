FILESEXTRAPATHS:prepend := "${THISDIR}/meson:"

SRC_URI += "file://0004-xuantie.patch"
