OS_RELEASE_FIELDS_append = " HOME_URL "
HOME_URL = "https://occ.t-head.cn/"
