RRECOMMENDS_${PN}_remove = "weston-init"
