RDEPENDS_${PN}-utils_remove = "${VIRTUAL-RUNTIME_graphical_init_manager}"
