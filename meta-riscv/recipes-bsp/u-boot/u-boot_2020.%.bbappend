FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

LIC_FILES_CHKSUM = "file://Licenses/README;md5=30503fd321432fc713238f582193b78e"


SRC_URI = " \
            git://git@gitlab.alibaba-inc.com/thead-linux/u-boot.git;protocol=ssh \ 
          "

SRCREV = "a47a14760e3925959af862bf53d6b3e36a348352"
