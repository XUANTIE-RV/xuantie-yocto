COMPATIBLE_MACHINE = "ice|light-fm|light-mpw"
