require ${BPN}.inc
inherit xuantie-gcc14-compatible
SRC_URI[sha256sum] = "e1066221bf7b89cb1fa7327a3888645cb33b604de3bf45aa81132fd040b699bf"
