CFLAGS += " -Wno-incompatible-pointer-types  -Wno-calloc-transposed-args  -Wno-deprecated-declarations -Wno-maybe-uninitialized -Wno-builtin-declaration-mismatch -Wno-implicit-function-declaration -Wno-pointer-to-int-cast -Wno-implicit-int -Wno-unused-result"
CXXFLAGS += "-Wno-dangling-reference"
