IMAGE_INSTALL += "resizefs"
